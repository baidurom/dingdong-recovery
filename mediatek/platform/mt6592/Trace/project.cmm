global &project
&project="mt6592_evb"
